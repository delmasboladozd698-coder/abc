# Keil uVision project template.uvprojx, settings and files
target template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\SYS;..\User\hx711;..\SYS\my_usart;..\Project
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SYS
    ../SYS/: main.c sys.c
    ../SYS/menu/: menu.c
    ../SYS/time/: time2.c
    ../SYS/flash/: BridgeFlash.c
    ../SYS/my_usart/: my_usart2.c
  group USER
    ../User/beep/: bsp_beep.c
    ../User/led/: led.c
    ../User/key/: key.c
    ../User/: stm32f10x_it.c
    ../User/oled/: bsp_oled_iic.c
    ../User/adc/: adc.c
    ../User/illumination/: illumination.c
    ../User/dht11/: DHT11.c
    ../User/mqttwifi/: esp8266_drv.c mqtt_drv.c
    ./: motor.h motor.c pid.c pid.h
    ../User/delay/: delay.c delay.h
    ../User/relay/: relay.c relay.h
  group STARTUP
    ../Libraries/CMSIS/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
